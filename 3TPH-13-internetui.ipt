# Autodesk Inventor part: 5TPH-13-internetui
## iProperties
Created: 2010-10
Part Number: 5TPH-13-internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
